FILESEXTRAPATHS:prepend:tb-efi := "${THISDIR}/files:"

hostname = "tb"
