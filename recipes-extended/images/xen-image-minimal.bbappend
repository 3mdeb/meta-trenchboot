IMAGE_FEATURES:append = " ssh-server-openssh"

IMAGE_INSTALL:append = " \
                        packagegroup-tb-base \
                        packagegroup-tb-utils \
                        packagegroup-tb-tests \
                        "
