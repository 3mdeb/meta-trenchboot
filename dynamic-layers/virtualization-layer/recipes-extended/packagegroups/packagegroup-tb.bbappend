RDEPENDS:${PN}-virtualization += "\
    ipxe \
"
