EXTRA_OECONF += "--with-udevrulesdir=/lib/udev/rules.d/"

FILES_${PN} = "\
    /lib/udev \
"
