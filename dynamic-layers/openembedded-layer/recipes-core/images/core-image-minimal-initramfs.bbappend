IMAGE_INSTALL_append = " \
    initramfs-tools \
    cryptsetup \
    lvm2 \
"
