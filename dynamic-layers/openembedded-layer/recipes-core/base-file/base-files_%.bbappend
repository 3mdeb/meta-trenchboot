FILESEXTRAPATHS_prepend_tb-efi := "${THISDIR}/files:"

hostname = "tb"
